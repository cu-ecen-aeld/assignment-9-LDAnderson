## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
       bool "LDD"
       help
         Includes the scull sample driver, hello world and misc-modules components
```
